# Repository unyacat/td4

File README.md:

# TD4

渡波郁著 [CPUの創りかた](https://book.mynavi.jp/ec/products/detail/id=22065) 独自に起こした基板です。

## 必要な部品・値段

大まかの目安です。

|部品|個数|参考価格|内容|情報|
|---|---|---|---|---|
|74HC10|1|@60|3入力NAND回路||
|74HC14|1|@40|6回路シュミットトリガーインバータ||
|74HC32|1|@30|4回路OR||
|74HC74|1|@25|2回路Dフリップフロップ||
|74HC138|2|@30|3to8ラインデコーダ||
|74HC153|2|@180|4chマルチプレクサ||
|74HC161|4|@80|同期式4ビットカウンタ||
|74HC283|1|@220|4bit 2進全加算器||
|74HC540|1|@200|8bit 3ステートバッファ(反転タイプ)||
|USB Type-Cコネクタ|1|@70|電源供給用|[秋月](https://akizukidenshi.com/catalog/g/g116438/)|
|スライドスイッチ|1|@30|2.54mmピッチ|手動クロックと自動クロックを選択する用|
|0.1uF|14||積層セラミックコンデンサ|ICの近くに配置する用|
|10uF|3||無極性電解コンデンサ|自動クロック・手動クロック・リセット用|
|100Ω|8|||LED用|
|1kΩ|5||||
|5.1kΩ|2|||Type-Cから5V取る用|
|10kΩ|9||||
|33kΩ|1|||自動クロック用|
|100kΩ|1|||リセット回路用|
|LED|8||||
|DIPスイッチ 4P|1|@100||入力用|
|DIPスイッチ 8P|16|@110||ROM用|
|ICソケット 8P|1|10@100|||
|ICソケット 14P|4|10@120|||
|ICソケット 16P|25|10@180|||
|ICソケット 20P|1|10@170|||
|ダイオード|128|200@200|1S1588相当品|200個セットで購入|
|プッシュスイッチ|1||3.5mmピッチ|リセットボタン用|
|プッシュスイッチ|1||6mmピッチ角|手動クロック用|
|スペーサー|8|@50||四隅につけることができます|
|基板|1|5@3500||JLCPCB発注、送料込み|

## 既知の不具合

* ROM横のLEDの表示が反転しています。ROMが選択されていないときは点灯し、選択されているときは消灯します。
  * LEDにつながっているGNDを5Vに置き換えることで修正可能だと思われます。上の部品リストには含んでいません。

## KiCad design td4.kicad_pcb

Schematic: td4.kicad_sch

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C10, C11, C12, C14, C15, C16, C17, C18: C; C_Rect_L7.0mm_W2.5mm_P5.00mm
C13: 10u; C_Rect_L7.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152: LED; LED_D3.0mm
D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132: D; Diode_THT_D_DO-35_SOD27_P5.08_Vertival_AnodeUp-no-circle
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
J2: Conn_01x01_Socket; PinHeader_1x01_P1.27mm_Vertical
R1: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18, R20: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21, R22: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DIP_x04; DIP-8_W7.62mm
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: SW_DIP_x08; DIP-16_W7.62mm_Socket
SW18: SW_Push; SW_PUSH_1P1T_6x3.5mm_H5.0_APEM_MJTP1250
SW19: SW_SPDT; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW20: SW_Push; SW_PUSH_6mm_H13mm
U1: 74HC14; DIP-14_W7.62mm_Socket
U2, U3, U4, U5: 74HC161AP; DIP-16_W7.62mm_Socket; MPN 74HC161N
U6, U7: CD74HC153; DIP-16_W7.62mm_Socket
U8: CD74HC283; DIP-16_W7.62mm_Socket
U9: CD74HC74; DIP-14_W7.62mm_Socket
U10: CD74HC10; DIP-14_W7.62mm_Socket
U11: CD74HC32; DIP-14_W7.62mm_Socket
U13: CD74HC540; DIP-20_W7.62mm_Socket
U14, U15: 74HC138; DIP-16_W7.62mm_Socket

Connections:
unnamed: C1.1, R1.1, U1.1
unnamed: C12.2, R19.2, U1.5
unnamed: C13.2, R20.2, SW20.2, U1.11
unnamed: D1.2 (A), R6.2
unnamed: D2.2 (A), R7.2
unnamed: D3.2 (A), R8.2
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), SW2.1
unnamed: D6.2 (A), SW2.2
unnamed: D7.2 (A), SW2.3
unnamed: D8.2 (A), SW2.4
unnamed: D9.2 (A), SW2.5
unnamed: D10.2 (A), SW2.6
unnamed: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), R27.1, U14.15 (~Y0)
unnamed: D11.2 (A), SW2.7
unnamed: D12.2 (A), SW2.8
unnamed: D13.2 (A), SW3.1
unnamed: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), R28.1, U14.14 (~Y1)
unnamed: D14.2 (A), SW3.2
unnamed: D15.2 (A), SW3.3
unnamed: D16.2 (A), SW3.4
unnamed: D17.2 (A), SW3.5
unnamed: D18.2 (A), SW3.6
unnamed: D19.2 (A), SW3.7
unnamed: D20.2 (A), SW3.8
unnamed: D21.2 (A), SW4.1
unnamed: D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), R29.1, U14.13 (~Y2)
unnamed: D22.2 (A), SW4.2
unnamed: D23.2 (A), SW4.3
unnamed: D24.2 (A), SW4.4
unnamed: D25.2 (A), SW4.5
unnamed: D26.2 (A), SW4.6
unnamed: D27.2 (A), SW4.7
unnamed: D28.2 (A), SW4.8
unnamed: D29.2 (A), SW5.1
unnamed: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), R30.1, U14.12 (~Y3)
unnamed: D30.2 (A), SW5.2
unnamed: D31.2 (A), SW5.3
unnamed: D32.2 (A), SW5.4
unnamed: D33.2 (A), SW5.5
unnamed: D34.2 (A), SW5.6
unnamed: D35.2 (A), SW5.7
unnamed: D36.2 (A), SW5.8
unnamed: D37.2 (A), SW6.1
unnamed: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), R31.1, U14.11 (~Y4)
unnamed: D38.2 (A), SW6.2
unnamed: D39.2 (A), SW6.3
unnamed: D40.2 (A), SW6.4
unnamed: D41.2 (A), SW6.5
unnamed: D42.2 (A), SW6.6
unnamed: D43.2 (A), SW6.7
unnamed: D44.2 (A), SW6.8
unnamed: D45.2 (A), SW7.1
unnamed: D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), R32.1, U14.10 (~Y5)
unnamed: D46.2 (A), SW7.2
unnamed: D47.2 (A), SW7.3
unnamed: D48.2 (A), SW7.4
unnamed: D49.2 (A), SW7.5
unnamed: D50.2 (A), SW7.6
unnamed: D51.2 (A), SW7.7
unnamed: D52.2 (A), SW7.8
unnamed: D53.2 (A), SW8.1
unnamed: D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), R42.1, U14.9 (~Y6)
unnamed: D54.2 (A), SW8.2
unnamed: D55.2 (A), SW8.3
unnamed: D56.2 (A), SW8.4
unnamed: D57.2 (A), SW8.5
unnamed: D58.2 (A), SW8.6
unnamed: D59.2 (A), SW8.7
unnamed: D60.2 (A), SW8.8
unnamed: D61.2 (A), SW9.1
unnamed: D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), R33.1, U14.7 (~Y7)
unnamed: D62.2 (A), SW9.2
unnamed: D63.2 (A), SW9.3
unnamed: D64.2 (A), SW9.4
unnamed: D65.2 (A), SW9.5
unnamed: D66.2 (A), SW9.6
unnamed: D67.2 (A), SW9.7
unnamed: D68.2 (A), SW9.8
unnamed: D69.2 (A), SW10.1
unnamed: D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), R34.1, U15.15 (~Y0)
unnamed: D70.2 (A), SW10.2
unnamed: D71.2 (A), SW10.3
unnamed: D72.2 (A), SW10.4
unnamed: D73.2 (A), SW10.5
unnamed: D74.2 (A), SW10.6
unnamed: D75.2 (A), SW10.7
unnamed: D76.2 (A), SW10.8
unnamed: D77.2 (A), SW11.1
unnamed: D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), R35.1, U15.14 (~Y1)
unnamed: D78.2 (A), SW11.2
unnamed: D79.2 (A), SW11.3
unnamed: D80.2 (A), SW11.4
unnamed: D81.2 (A), SW11.5
unnamed: D82.2 (A), SW11.6
unnamed: D83.2 (A), SW11.7
unnamed: D84.2 (A), SW11.8
unnamed: D85.2 (A), SW12.1
unnamed: D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), R36.1, U15.13 (~Y2)
unnamed: D86.2 (A), SW12.2
unnamed: D87.2 (A), SW12.3
unnamed: D88.2 (A), SW12.4
unnamed: D89.2 (A), SW12.5
unnamed: D90.2 (A), SW12.6
unnamed: D91.2 (A), SW12.7
unnamed: D92.2 (A), SW12.8
unnamed: D93.2 (A), SW13.1
unnamed: D94.2 (A), SW13.2
unnamed: D95.2 (A), SW13.3
unnamed: D96.2 (A), SW13.4
unnamed: D97.2 (A), SW13.5
unnamed: D98.2 (A), SW13.6
unnamed: D99.2 (A), SW13.7
unnamed: D100.2 (A), SW13.8
unnamed: D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), R37.1, U15.12 (~Y3)
unnamed: D101.2 (A), SW14.1
unnamed: D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), R38.1, U15.11 (~Y4)
unnamed: D102.2 (A), SW14.2
unnamed: D103.2 (A), SW14.3
unnamed: D104.2 (A), SW14.4
unnamed: D105.2 (A), SW14.5
unnamed: D106.2 (A), SW14.6
unnamed: D107.2 (A), SW14.7
unnamed: D108.2 (A), SW14.8
unnamed: D109.2 (A), SW15.1
unnamed: D109.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), D113.1 (K), D114.1 (K), D115.1 (K), D116.1 (K), R39.1, U15.10 (~Y5)
unnamed: D110.2 (A), SW15.2
unnamed: D111.2 (A), SW15.3
unnamed: D112.2 (A), SW15.4
unnamed: D113.2 (A), SW15.5
unnamed: D114.2 (A), SW15.6
unnamed: D115.2 (A), SW15.7
unnamed: D116.2 (A), SW15.8
unnamed: D117.2 (A), SW16.1
unnamed: D117.1 (K), D118.1 (K), D119.1 (K), D120.1 (K), D121.1 (K), D122.1 (K), D123.1 (K), D124.1 (K), R40.1, U15.9 (~Y6)
unnamed: D118.2 (A), SW16.2
unnamed: D119.2 (A), SW16.3
unnamed: D120.2 (A), SW16.4
unnamed: D121.2 (A), SW16.5
unnamed: D122.2 (A), SW16.6
unnamed: D123.2 (A), SW16.7
unnamed: D124.2 (A), SW16.8
unnamed: D125.2 (A), SW17.1
unnamed: D125.1 (K), D126.1 (K), D127.1 (K), D128.1 (K), D129.1 (K), D130.1 (K), D131.1 (K), D132.1 (K), R41.1, U15.7 (~Y7)
unnamed: D126.2 (A), SW17.2
unnamed: D127.2 (A), SW17.3
unnamed: D128.2 (A), SW17.4
unnamed: D129.2 (A), SW17.5
unnamed: D130.2 (A), SW17.6
unnamed: D131.2 (A), SW17.7
unnamed: D132.2 (A), SW17.8
unnamed: D133.2 (A), R23.2
unnamed: D134.2 (A), R24.2
unnamed: D135.2 (A), R25.2
unnamed: D136.2 (A), R26.2
unnamed: D137.2 (A), R27.2
unnamed: D138.2 (A), R28.2
unnamed: D139.2 (A), R29.2
unnamed: D140.2 (A), R30.2
unnamed: D141.2 (A), R31.2
unnamed: D142.2 (A), R32.2
unnamed: D143.2 (A), R33.2
unnamed: D144.2 (A), R34.2
unnamed: D145.2 (A), R35.2
unnamed: D146.2 (A), R36.2
unnamed: D147.2 (A), R37.2
unnamed: D148.2 (A), R38.2
unnamed: D149.2 (A), R39.2
unnamed: D150.2 (A), R40.2
unnamed: D151.2 (A), R41.2
unnamed: D152.2 (A), R42.2
unnamed: J1.A5 (CC1), R21.1
unnamed: J1.B5 (CC2), R22.1
unnamed: R1.2, U1.2, U1.3
unnamed: R6.1, U4.14 (A)
unnamed: R7.1, U4.13 (B)
unnamed: R8.1, U4.12 (C)
unnamed: R9.1, U4.11 (D)
unnamed: R18.2, R19.1, SW18.2
unnamed: C1.2, SW19.3 (A), U1.4
unnamed: R24.1, SW19.1 (B), U2.2 (CK), U3.2 (CK), U4.2 (CK), U5.2 (CK), U9.3 (CP)
unnamed: SW19.2 (C), U1.10
unnamed: U1.6, U1.9
unnamed: R25.1, U1.8, U2.1 (-CLR), U3.1 (-CLR), U4.1 (-CLR), U5.1 (-CLR), U9.1 (~R)
unnamed: U2.9 (-LOAD), U11.6
unnamed: U3.9 (-LOAD), U11.8
unnamed: U4.9 (-LOAD), U10.6
unnamed: U5.9 (-LOAD), U10.8
unnamed: U2.14 (A), U6.6 (1I0)
unnamed: U3.14 (A), U6.5 (1I1)
unnamed: R5.1, SW1.5, U6.4 (1I2)
unnamed: U6.7 (1Y), U8.5 (A0)
unnamed: U2.13 (B), U6.10 (2I0)
unnamed: U3.13 (B), U6.11 (2I1)
unnamed: R4.1, SW1.6, U6.12 (2I2)
unnamed: U6.9 (2Y), U8.3 (A1)
unnamed: U6.14 (S0), U7.14 (S0), U11.3
unnamed: U2.12 (C), U7.6 (1I0)
unnamed: U3.12 (C), U7.5 (1I1)
unnamed: R3.1, SW1.7, U7.4 (1I2)
unnamed: U7.7 (1Y), U8.14 (A2)
unnamed: U2.11 (D), U7.10 (2I0)
unnamed: U3.11 (D), U7.11 (2I1)
unnamed: R2.1, SW1.8, U7.12 (2I2)
unnamed: U7.9 (2Y), U8.12 (A3)
unnamed: U8.9 (COUT), U9.2 (D)
unnamed: U2.3 (A), U3.3 (A), U4.3 (A), U5.3 (A), U8.4 (S0)
unnamed: U2.4 (B), U3.4 (B), U4.4 (B), U5.4 (B), U8.1 (S1)
unnamed: U2.5 (C), U3.5 (C), U4.5 (C), U5.5 (C), U8.13 (S2)
unnamed: U2.6 (D), U3.6 (D), U4.6 (D), U5.6 (D), U8.10 (S3)
unnamed: R26.1, U9.5 (Q)
unnamed: U9.6 (~Q), U11.13
unnamed: U10.11, U11.11
unnamed: U10.4, U10.12, U11.9
unnamed: R17.2, SW2.9, SW3.9, SW4.9, SW5.9, SW6.9, SW7.9, SW8.9, SW9.9, SW10.9, SW11.9, SW12.9, SW13.9, SW14.9, SW15.9, SW16.9, SW17.9, U13.2 (A0)
unnamed: R16.2, SW2.10, SW3.10, SW4.10, SW5.10, SW6.10, SW7.10, SW8.10, SW9.10, SW10.10, SW11.10, SW12.10, SW13.10, SW14.10, SW15.10, SW16.10, SW17.10, U13.3 (A1)
unnamed: R15.2, SW2.11, SW3.11, SW4.11, SW5.11, SW6.11, SW7.11, SW8.11, SW9.11, SW10.11, SW11.11, SW12.11, SW13.11, SW14.11, SW15.11, SW16.11, SW17.11, U13.4 (A2)
unnamed: R14.2, SW2.12, SW3.12, SW4.12, SW5.12, SW6.12, SW7.12, SW8.12, SW9.12, SW10.12, SW11.12, SW12.12, SW13.12, SW14.12, SW15.12, SW16.12, SW17.12, U13.5 (A3)
unnamed: R13.2, SW2.13, SW3.13, SW4.13, SW5.13, SW6.13, SW7.13, SW8.13, SW9.13, SW10.13, SW11.13, SW12.13, SW13.13, SW14.13, SW15.13, SW16.13, SW17.13, U13.6 (A4)
unnamed: R12.2, SW2.14, SW3.14, SW4.14, SW5.14, SW6.14, SW7.14, SW8.14, SW9.14, SW10.14, SW11.14, SW12.14, SW13.14, SW14.14, SW15.14, SW16.14, SW17.14, U13.7 (A5)
unnamed: R11.2, SW2.15, SW3.15, SW4.15, SW5.15, SW6.15, SW7.15, SW8.15, SW9.15, SW10.15, SW11.15, SW12.15, SW13.15, SW14.15, SW15.15, SW16.15, SW17.15, U13.8 (A6)
unnamed: R10.2, SW2.16, SW3.16, SW4.16, SW5.16, SW6.16, SW7.16, SW8.16, SW9.16, SW10.16, SW11.16, SW12.16, SW13.16, SW14.16, SW15.16, SW16.16, SW17.16, U13.9 (A7)
unnamed: U10.5, U10.10, U11.2, U11.5, U11.10, U13.18 (~Y0)
unnamed: U10.9, U10.13, U11.4, U13.17 (~Y1)
unnamed: U6.2 (S1), U7.2 (S1), U13.16 (~Y2)
unnamed: U11.1, U11.12, U13.15 (~Y3)
unnamed: U8.11 (B3), U13.14 (~Y4)
unnamed: U8.15 (B2), U13.13 (~Y5)
unnamed: U8.2 (B1), U13.12 (~Y6)
unnamed: U8.6 (B0), U13.11 (~Y7)
unnamed: U5.14 (A), U14.1 (A0), U15.1 (A0)
unnamed: U5.13 (B), U14.2 (A1), U15.2 (A1)
unnamed: U5.12 (C), U14.3 (A2), U15.3 (A2)
unnamed: U5.11 (D), U14.4 (~E0), U14.5 (~E1), U15.6 (E2)

Notes on the sheet:
OP0
P.185
-LOAD1
フリップフロップ
0000
ROMアドレスの選択
Reset
Clock
SELECT A
Set
配線: P.227
ROMアドレスの選択 4bit -> 16bit
基板では 左MSB -> LSB右 回路図では 左LSB -> MSB右
加算器
P.206
OP3
C確認用LED
MSB
P.211
LSB
シュミットトリガ 反転
OP2
P.84
P.221
P.175
キャリーフラグ
OP1
3210
右から左にへ処理される
RST確認用LED
ROMへ
イミディエイトデータ
-LOAD3
P.272
ROM
手動クロック
ROMのアドレスを指定
プログラムカウンタ
キャリーをメモする
クロック

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
Board: 2 copper layers, 238.8 x 120.6 mm, 251 parts (0 on the bottom side), 236 nets.

## Commit log

2025-01-26 Rev.2
